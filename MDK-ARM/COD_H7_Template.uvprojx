# Keil uVision project COD_H7_Template.uvprojx, settings and files
target COD_H7_Template (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: COD_H7_Template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../Task/Inc;../Device/Inc;../Algorithm/Inc;../Middlewares/ST/ARM/DSP/Inc;../API/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../SystemView/SEGGER;../SystemView/Sample/FreeRTOSV10;../SystemView/Config;../SystemView/SEGGER/Syscalls;../SystemView/Sample/FreeRTOSV10/Patch;../UI/Inc
  asm include: ../Core/Inc;../Middlewares/ST/ARM/DSP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: COD_H7_Template\COD_H7_Template.sct
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Bsp
    ../BSP/Src/: bsp_can.c bsp_uart.c bsp_gpio.c bsp_pwm.c bsp_tick.c bsp_rs485.c bsp_spi.c bsp_adc.c bsp_buzzer.c
  group Task
    ../Task/Src/: Control_Task.c INS_Task.c CAN_Task.c Warning_Task.c Magazine_task.c Control_Gaimbal_Task.c Detect.c PowerContral.c
    ../Task/Inc/: Config.h Control_Gaimbal_task.h Detect.h PowerContral.h
  group Device
    ../Device/Src/: Motor.c remote_control.c Referee_System.c Bmi088.c DM_imu.c rc_vtm_ccontrol.c
    ../Device/Inc/: Bmi088_Reg.h DM_imu.h rc_vtm_control.h
  group Algorithm
    ../Algorithm/Src/: Kalman_Filter.c lpf.c pid.c ramp.c CRC.c RLS.c Q_math.c Power.c matrix.c slidingmode.c
    ../Algorithm/Inc/: arm_math.h slidingmode.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group DSP
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM7lfdp_math.lib
  group API
    ../API/Src/: Quaternion.c
software components: CMSIS:CORE 6.1.0
